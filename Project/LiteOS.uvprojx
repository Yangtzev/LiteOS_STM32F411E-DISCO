# Keil uVision project LiteOS.uvprojx, settings and files
target LiteOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LiteOS_STM32F411E-DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411XE
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\LiteOS\arch\arm\arm-m\cortex-m4;..\LiteOS\arch\arm\arm-m\include;..\LiteOS\cmsis\1.0;..\LiteOS\cmsis\2.0;..\LiteOS\cmsis;..\LiteOS\kernel\include;..\LiteOS\kernel\base\include;..\LiteOS\kernel\extended\include;..\LiteOS\OS_CONFIG;..\User\BSP\STM32F411E-Discovery;..\User\BSP\Components\Common;..\User\BSP\Components\lsm303agr;..\User\BSP\Components\lsm303dlhc;..\User\AI-run-1-model-network-code\AI\App;..\User\AI-run-1-model-network-code\generated;..\User\AI-run-1-model-network-code\Middlewares\ST\AI\Inc;..\User\AI-run-1-model-network-code\Middlewares\ST\AI\Misc\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group USER
    ../User/: main.c stm32f4xx_it.c board.c core_delay.c app_activity.c app_button.c app_config.c app_hw.c app_modes.c
    ../User/usart/: bsp_debug_usart.c
    ../User/BSP/STM32F411E-Discovery/: stm32f411e_discovery.c stm32f411e_discovery_accelerometer.c
    ../User/BSP/Components/lsm303agr/: lsm303agr.c
    ../User/BSP/Components/lsm303dlhc/: lsm303dlhc.c
  group LiteOS/cmsis
    ../LiteOS/cmsis/: cmsis_liteos.c
  group LiteOS/kernel
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memory.c los_memcheck.c
    ../LiteOS/kernel/base/mem/common/: los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/kernel/: los_init.c
  group LiteOS/arch
    ../LiteOS/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/config
    ../LiteOS/OS_CONFIG/: target_config.h
  group AI
    ../User/AI-run-1-model-network-code/Middlewares/ST/AI/Lib/: NetworkRuntime1200_CM4_Keil.lib
    ../User/AI-run-1-model-network-code/AI/App/: app_x-cube-ai.c
    ../User/AI-run-1-model-network-code/generated/: network.c network_data.c
    ../User/AI-run-1-model-network-code/Middlewares/ST/AI/Misc/Src/: ai_device_adaptor.c aiTestHelper_ST_AI.c aiTestUtility.c lc_print.c syscalls.c
  group DOC
    ../Doc/: readme.txt
